* C:\Users\Lenovo\eSim-Workspace\oscillator1\oscillator1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/19/25 14:37:27

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
M5  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M5-Pad3_ Net-_M10-Pad4_ mosfet_p
M9  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M10-Pad1_ Net-_M10-Pad4_ mosfet_p
M13  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M13-Pad3_ Net-_M10-Pad4_ mosfet_p
M17  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M17-Pad3_ Net-_M10-Pad4_ mosfet_p
M21  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M21-Pad3_ Net-_M10-Pad4_ mosfet_p
M6  Net-_M5-Pad3_ Out Net-_M10-Pad2_ Net-_M10-Pad4_ mosfet_p
M10  Net-_M10-Pad1_ Net-_M10-Pad2_ Net-_M10-Pad3_ Net-_M10-Pad4_ mosfet_p
M14  Net-_M13-Pad3_ Net-_M10-Pad3_ Net-_M11-Pad1_ Net-_M10-Pad4_ mosfet_p
M18  Net-_M17-Pad3_ Net-_M11-Pad1_ Net-_M15-Pad1_ Net-_M10-Pad4_ mosfet_p
M22  Net-_M21-Pad3_ Net-_M15-Pad1_ Out Net-_M10-Pad4_ mosfet_p
M2  Net-_M10-Pad4_ Net-_M1-Pad1_ Net-_M1-Pad1_ Net-_M10-Pad4_ mosfet_p
M3  Net-_M10-Pad2_ Out Net-_M3-Pad3_ GND mosfet_n
M7  Net-_M10-Pad3_ Net-_M10-Pad2_ Net-_M7-Pad3_ GND mosfet_n
M11  Net-_M11-Pad1_ Net-_M10-Pad3_ Net-_M11-Pad3_ GND mosfet_n
M15  Net-_M15-Pad1_ Net-_M11-Pad1_ Net-_M15-Pad3_ GND mosfet_n
M19  Out Net-_M15-Pad1_ Net-_M19-Pad3_ GND mosfet_n
M4  Net-_M3-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
M8  Net-_M7-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
M12  Net-_M11-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
M16  Net-_M15-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
M20  Net-_M19-Pad3_ Net-_M1-Pad2_ GND GND mosfet_n
M1  Net-_M1-Pad1_ Net-_M1-Pad2_ GND GND mosfet_n
v1  Net-_M1-Pad2_ GND DC
v2  Net-_M10-Pad4_ GND DC
U1  Out plot_v1

.end
